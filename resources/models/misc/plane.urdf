Commit message: Fix for Bullet issues

File: resources/models/misc/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=100 100 10; visual mesh filename=plane.obj scale=5 5 5
